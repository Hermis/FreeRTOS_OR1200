# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: IAR_ARMCM3_LM
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: LuminaryCode; ..\..\Source\include; ..\Common\include; .
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: BUILD_ALL; DEBUG; ewarm
  AARM.AUserIncludes: .
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3S811.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo Source
    ../Common/Minimal/: BlockQ.c integer.c PollQ.c semtest.c
    ./: main.c startup.c
    LuminaryCode/: osram96x16.c
  group Scheduler Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
